# Keil uVision project main.uvproj, settings and files
target LED_MATRIX (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED_MATRIX +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c main.h delay.c delay.h
